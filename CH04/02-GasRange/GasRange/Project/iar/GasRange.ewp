# IAR project GasRange.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\zonesion\Source; ..\..\zonesion\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\zonesion\Libraries\CMSIS\Include; ..\..\zonesion\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\zonesion\Libraries; ..\..\zonesion\Source\common\lcd; ..\..\zonesion\Source\common\sys; ..\..\zonesion\Source\common; ..\..\zonesion\Source\dev
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GasRange.hex
  ILINK.IlinkOutputFile: Grating.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f407xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../zonesion/Source/: readme.txt
  group dev
    ../../zonesion/Source/dev/: buzzer.c Flame.c MP-4.c Relay.c timer.c
  group Libraries/CMSIS
    ../../zonesion/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Libraries/FWLIB
    ../../zonesion/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Libraries/STARTUP
    ../../zonesion/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
  group picture
    ../../zonesion/Source/picture/: aux_logo.c flame_big_off.c flame_big_on.c flame_high_off.c flame_high_on.c flame_medium_off.c flame_medium_on.c flame_off.c flame_on_1.c flame_on_2.c flame_on_3.c flame_on_4.c flame_small_off.c flame_small_on.c gas_leakage_f.c gas_leakage_t.c identification.c picture.h total_switch_off.c total_switch_on.c
  group Source
    ../../zonesion/Source/common/sys/: delay.c key.c led.c rgb.c spi.c usart.c w25qxx.c
    ../../zonesion/Source/common/lcd/: ili9806.c text.c
    ../../zonesion/Source/common/: lcd.c
    ../../zonesion/Source/: main.c
