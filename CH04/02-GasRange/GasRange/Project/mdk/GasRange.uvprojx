# Keil uVision project GasRange.uvprojx, settings and files
target GasRange (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GasRange +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F40XX
  c misc: --diag_suppress=1,177,550
  c include: ..\..\zonesion\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\zonesion\Libraries\CMSIS\Include;..\..\zonesion\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\zonesion\Libraries;..\..\zonesion\Source\common\sys;..\..\zonesion\Source\common\lcd;..\..\zonesion\Source\common;..\..\zonesion\Source\dev;..\..\zonesion\Source;..\..\zonesion\Source\picture
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../zonesion/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group FWLIB
    ../../zonesion/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STARTUP
    ../../zonesion/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group Source
    ../../zonesion/Source/: main.c
    ../../zonesion/Source/common/sys/: delay.c key.c led.c spi.c usart.c w25qxx.c rgb.c
    ../../zonesion/Source/common/lcd/: ili9806.c text.c
    ../../zonesion/Source/common/: lcd.c
  group dev
    ../../zonesion/Source/dev/: Flame.c buzzer.c MP-4.c timer.c Relay.c
    ../../zonesion/Source/: readme.txt
  group picture
    ../../zonesion/Source/picture/: aux_logo.c flame_big_off.c flame_big_on.c flame_high_off.c flame_high_on.c flame_medium_off.c flame_medium_on.c flame_off.c flame_on_1.c flame_on_2.c flame_on_3.c flame_on_4.c flame_small_off.c flame_small_on.c gas_leakage_f.c gas_leakage_t.c identification.c total_switch_off.c total_switch_on.c
