# IAR project WashingMachine.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\zonesion\Source; ..\..\zonesion\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\zonesion\Libraries\CMSIS\Include; ..\..\zonesion\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\zonesion\Libraries; ..\..\zonesion\Source\common\lcd; ..\..\zonesion\Source\common\sys; ..\..\zonesion\Source\common; ..\..\zonesion\Source\dev; ..\..\zonesion\Source\gui; ..\..\zonesion\Source\picture
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WashingMachine.hex
  ILINK.IlinkOutputFile: Grating.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f407xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../zonesion/Source/: readme.txt
  group dev
    ../../zonesion/Source/dev/: buzzer.c Relay.c stepmotor.c timer.c
    ../../zonesion/Source/gui/: screen.c
  group Libraries/CMSIS
    ../../zonesion/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Libraries/FWLIB
    ../../zonesion/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Libraries/STARTUP
    ../../zonesion/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
  group picture
    ../../zonesion/Source/picture/: all_mode.c all_mode_1.c amount_of_water.c b_num_0.c b_num_1.c b_num_2.c b_num_3.c b_num_4.c b_num_5.c b_num_6.c b_num_7.c b_num_8.c b_num_9.c b_point.c dehydration.c dehydration_1.c rinseing.c rinseing_1.c s_num_0.c s_num_1.c s_num_2.c s_num_3.c s_num_4.c s_num_5.c s_num_6.c s_num_7.c s_num_8.c s_num_9.c soaking.c soaking_1.c total_switch_off.c total_switch_on.c unit.c washing.c washing_1.c washing_logo.c
  group Source
    ../../zonesion/Source/common/sys/: delay.c key.c led.c rgb.c spi.c usart.c w25qxx.c
    ../../zonesion/Source/common/lcd/: ili9806.c text.c
    ../../zonesion/Source/common/: lcd.c
    ../../zonesion/Source/: main.c
